# Keil uVision project emvloopback_usecase.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MAX32550 Maxim Integrated
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x10000020-0x100FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3") ELITTLE
  output: emvloopback +hex
  AfterMake: ..\..\tools\signit.bat "$K" "$L" "!L" "@L" $D
  c flags: Optim=1
  c misc: --c99
  c include: src;../../drivers/max3255X/include;../../drivers/max3255X/include/sci;../../drivers/max3255X/include/arch;../../drivers/max3255X/include/dev;../../include;src/protocol/emv/include;..\..\drivers\max3255X\include\sci\afe;..\..\drivers\max3255X\include\sci\uart
  memory RVCT4: ROM 0x10000020 size 0xfffe0
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    src/: main.c private.c
    ./src/: startup_max3255X.s printf_lite.c
    ../../drivers/common/: common.c
    ../../drivers/max3255X/source/: mml_dma.c mml_gcr.c mml_gpio.c mml_i2c.c mml_intc.c mml_mcr.c mml_rtc.c mml_sflc.c mml_skbd.c mml_smon.c mml_spi.c mml_tmr.c mml_trng.c mml_uart.c mml_wdt.c
    ../../drivers/max3255X/source/sci/: ATR.c iccabstract.c OSWrapper.c ProtocolT0.c ProtocolT1.c ProtocolT1_BlockMgt.c PTS.c smartcard_api.c
    ../../drivers/max3255X/source/sci/afe/: MAX3255x_AFE.c
    ../../drivers/max3255X/source/sci/uart/: MAX325xx_UART.c
