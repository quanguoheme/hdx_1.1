# Keil uVision project libmml.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: libmml (library)
  c flags: Optim=1 uC99=1
  c misc: --wchar32
  c include: max3255X/include;max3255X/include/arch;max3255X/include/dev;../include;max3255X/include/sci;max3255X/include/sci/afe;max3255X/include/sci/uart;max3255X/include/usb/enumerate;max3255X/include/usb/devclass;max3255X/include/usb/core;max3255X/include/dev;max3255X/include/usb/core/arm;max3255X/include/arch
  group Source Group 1
    ./max3255X/source/: mml_dma.c mml_gcr.c mml_gpio.c mml_i2c.c mml_intc.c mml_mcr.c mml_sflc.c mml_skbd.c mml_spi.c mml_tmr.c mml_uart.c mml_wdt.c mml_rtc.c mml_smon.c mml_trng.c
  group Source Group 2
    ./max3255X/source/sci/: ATR.c iccabstract.c OSWrapper.c ProtocolT0.c ProtocolT1.c ProtocolT1_BlockMgt.c PTS.c smartcard_api.c
    ./max3255X/source/sci/afe/: MAX3255x_AFE.c
    ./max3255X/source/sci/uart/: MAX325xx_UART.c
  group Source Group 3
    ./max3255X/source/usb/core/: usb_event.c
    ./max3255X/source/usb/core/arm/: usb.c
    ./max3255X/source/usb/devclass/: cdc_acm.c fifo.c hid_kbd.c hid_raw.c
    ./max3255X/source/usb/enumerate/: enumerate.c
